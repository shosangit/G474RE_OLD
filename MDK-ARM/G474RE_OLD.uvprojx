# Keil uVision project G474RE_OLD.uvprojx, settings and files
target G474RE_OLD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G474RE_OLD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;                         ../Middlewares/ST/AI/Inc;                         ../X-CUBE-AI/App;                         ../Drivers/STM32G4xx_HAL_Driver/Inc;                         ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                         ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                         ../Drivers/CMSIS/Include;                        ../X-CUBE-AI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: BC20.c MPU6050.c main.c gpio.c crc.c dma.c i2c.c usart.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: network2_generate_report.txt
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime700_CM4_Keil.lib
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network2.c network2_data.c app_x-cube-ai.c
software components: CMSIS:CORE 4.3.0
